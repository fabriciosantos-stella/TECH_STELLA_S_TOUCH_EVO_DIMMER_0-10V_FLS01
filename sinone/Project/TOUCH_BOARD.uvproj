# Keil uVision project TOUCH_BOARD.uvproj, settings and files
target <TOUCH_BOARD> (MCS-51)
  device: SC95F8573 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: TOUCH_BOARD +hex
  c flags: Optimize=8
  c define: SC95F8x7x
  c include: ..\App;..\Drivers\SC95F_Lib\inc;..\User;..\Libs\TKDriver\C;..\Drivers\STELLA
  link misc: REMOVEUNUSED
  group App
    ../App/: Comm.c Slider.c Tasks.c Utils.c
  group User
    ../User/: main.c HwInit.c Interrupts.c
  group Drivers
    ../Drivers/SC95F_Lib/src/: sc95f_pwm.c sc95f_option.c sc95f_gpio.c sc95f_btm.c sc95f_wdt.c sc95f_uart0.c sc95f_usci2.c
  group Libs
    ../Libs/TKDriver/C/: TKDriver.C
    $TC_ROOT$/../../Temp/Repositorio/TECH_STELLA_S_TOUCH_EVO_DIMMER_PHASE_CUT/sinone//Libs/TKDriver/C/: SC95F8X7X_HighSensitive_Lib_Slide_L_V2.2.0.LIB
  group Startup
    ./: STARTUP.A51
